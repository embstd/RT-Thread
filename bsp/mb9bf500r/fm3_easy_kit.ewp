# IAR project fm3_easy_kit.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF500R Fujitsu MB9BF500R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ; CMSIS; ..\..\include; ..\..\components\rtgui\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  ILINK.IlinkOutputFile: fm3_easy_kit.out
  ILINK.IlinkIcfFile: mb9bf500r.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/: core_cm3.c start_iar.S system_mb9bf50x.c
  group FM3
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c rtm.c scheduler.c slab.c thread.c timer.c
  group Rtgui
    ../../components/rtgui/widgets/: about_view.c box.c button.c checkbox.c combobox.c container.c filelist_view.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c notebook.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c textbox.c textview.c title.c toplevel.c view.c widget.c window.c workbench.c
    ../../components/rtgui/common/: asc12font.c asc16font.c blit.c color.c dc.c dc_buffer.c dc_client.c dc_hw.c filerw.c font.c font_bmp.c font_freetype.c font_hz_bmp.c font_hz_file.c framebuffer_driver.c hz12font.c hz16font.c image.c image_bmp.c image_container.c image_hdc.c image_jpg.c image_png.c image_xpm.c pixel_driver.c region.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c
    ../../components/rtgui/server/: driver.c mouse.c panel.c server.c topwin.c
  group Startup
    ./: adc.c application.c board.c cpuusage.c info.c key.c lcd.c led.c startup.c
